# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app\CAR_GO;.\app\MOTOR;.\app\PID;.\app\PWM;.\public;.\user;.\app\XUNJI_PID;.\app\XUNJI_NOMAL;.\app\IO_DEFINITION;.\app\BT
  group user
    ./user/: main.c
  group public
    ./public/: public.c
  group app
    ./app/CAR_GO/: car_go.c
    ./app/MOTOR/: motor.c
    ./app/PWM/: pwm.c
    ./app/IO_DEFINITION/: io_definition.c
    ./app/XUNJI_NOMAL/: xunji_nomal.c xunji.c
    ./app/BT/: bt.c bt_go.c
